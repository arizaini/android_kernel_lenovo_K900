## drivers/fastpower/Kconfig
```kconfig
config FASTPOWER
	tristate "fastpower dev android driver"
	default n
	help
	  The fastpower dev and sys android driver
```
